# Keil uVision project spot_welding.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: spot_welding +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: __CX51__, __CONF_MCU_MODEL=MCU_MODEL_STC8G1K08, __CONF_FOSC=11059200UL
  c include: .\FwLib_STC8\include
  group Source Group 1
    ./: STARTUP.A51 main.c
  group FwLib_STC8
    ./FwLib_STC8/src/: fw_adc.c fw_sys.c fw_tim.c fw_uart.c
